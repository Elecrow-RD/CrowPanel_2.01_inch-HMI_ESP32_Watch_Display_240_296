# Repository Elecrow-RD/CrowPanel_2.01_inch-HMI_ESP32_Watch_Display_240_296

## EAGLE design Eagle_SCH&PCB/V1.0/ESP32 WATCH_V1.0.brd

Parts:
ANT1: OA-D3
C1, C2, C5, C9, C13, C14, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C35, C36, C37, C51, C52, C53, C64, C66: 100nF; C0402
C3: 2PF; C0402
C4: NC; C0402
C6, C34, C38, C39, C40: 10uF; C0402
C7, C8: 12pF/NC; C0402
C10, C15, C29, C30, C31: 1uF; C0402
C11, C12: 12pF; C0402
C32: 10uF; C0402@1
C33: 100nF; C0402@1
C42: 22pF; C0402
C67: 10uF; DISCRETE-NEW_C0402
C102: 1uF; C0402@1
C103, C104: 47uF; C0402
C105, C106: 1nF; C0402@1
D1, D3, D4: LESD5D5.0CT1G-ES; SOD-523_L1.2-W0.8-LS1.6-BI
D007: RB521S-30; SOD523
D9: C917117_1N4148WS; PICO-2.4_SOD-323
FB1, FB17: 0R/800mA; R0402
FB10, FB11: 1K/磁珠; R0402
FPC2: FPC-0.3HF-15P
FPC3: HC-FPC-0.3-15P-FH10; FPC-SMD_HC-FPC-0.3-15P-FH10
J1: VIB_MOTOR_8MM
J2, J4, J5, J6: CONN_011X01_2.6MM; 1X01_2.5MM
J3: USB_TYPE-C_16PIN3.0USB; KEVIN_3.0TYPEC-SMD
J7: ZX-SH1.0-2PLT1; CONN-SMD_2P-P1.00_XUNPU_WAFER-SH1.0-2PWB
L1: 6.8nH; L0402
L2: 0R; L0402
L3: 24nH; L0402
L4: 2nH; L0402
L5: 2.2μH_C5179446; 1008(2520)
LED1: RED; LED-0603
MIC3: LMD3526T261; SMD_6P_3.5X2.7MM
P1, P2, P3, P4, P5, P6, P9, P10, P11, P14, P15, P16, P54, P55: TEST_PADPAD-1.5MM; TEST_PAD-1.5MM
P7, P8: H_1_2X1
Q1, Q5: SI2301; DFN8_SOT-23
Q4, Q6: MMBT3904T; SOT-523
Q7, Q10: AO3401; PMOS_SOT23
R1: 10R; R0402
R2, R27, R37, R42, R56, R76: 1K; R0402
R3, R4, R9, R12, R13, R14, R22, R28, R38, R40, R65, R71, R75, R601: 10K; R0402
R5, R6, R26, R29, R39, R62, R63: 5.1K; R0402
R7, R16, R21, R24, R25, R43, R44, R66, R77, R78, R79: 22R; R0402
R10, R11, R34, R70: 0R; R0402
R15: 100K; 0402
R17: 22.1K; 0402
R18, R23: 22R; 0402
R19, R20: 5.1K; 0402
R30, R48, R139: 100K; R0402
R31: 62K; R0402
R32: 2.8K; R0402
R33: 100K 4250K NTC; R0402
R36: 137K; R0402
R57: 10M; R0402
R74: 3.9R; R0402
R143: 50K; R0402
R171: 0R/NC; R0402
SW1, SW2, SW3: KEY_SMT; SMD_4.1X3.2
U1: PCF8563; MSOP-8
U3: CH340K; ESOP-10-EP-150MIL
U4: UMH3NTN; SOP65P210X100-6N
U5: C3021085/TPAP2112K-3.3TRG1; SOT23-5
U6: LGS4056HDA; DFN2X2-8
U7: SC7A20HTR; LGA-12(2*2)
U8: W25Q128JVSIQ; SOIC127P790X216-8N
U9: ESP32-S3R8; QFN40P700X700X90-57N
U10: CST5106L; QFN20-3*3
U11: NS4168; NS4168-ESOP-8
U12: STC8G1K08; DFN8
U13: MT3406_C22462728; SOT95P280X145-5N
U55: E5A5; E5A5-2.35S10
X1: 40MHz(10ppm); ADAFRUIT_NX3225
Y3: 32.768K; NORDIC_NRF_XTAL_3215_N

Connections:
3V3: C1.2, C14.2, C40.2, C42.2, C52.1, C53.1, FB1.1, FB17.2, L5.2, Q1.2 (S), Q10.2 (S), R1.1, R15.1, R22.1, R57.2, R71.2, U7.P$3 (VDDIO), U7.P$7 (VDD)
AUDIO_EN: Q10.1 (G), R71.1, U9.36 (SPICLK_N)
AUDIO_VDD: Q10.3 (D), R139.2
AUDIO_VDD1: C102.1, C103.1, C104.1, FB17.1, U11.6 (VDD)
BAT+: C67.1, J7.2, Q5.3 (D), R30.2, U6.P$5 (BAT)
BAT_ADC: C26.2, R30.1, R36.1, U9.6 (GPIO1)
BL_EN: R76.2, U9.18 (GPIO13)
CHRG: R34.2, U9.21 (XTAL_32K_P)
CHRG_1: R5.2, R28.1, R34.1, U6.P$7 (CHRG)
D+: J3.A6 (DP1), J3.B6 (DP2), R23.2
D-: J3.A7 (DN1), J3.B7 (DN2), R18.2
DISPLAY_EN: R56.2, U9.45 (MTDO)
DISPLAY_VDD: C22.2, C25.2, C27.2, FPC3.5, FPC3.6, FPC3.7, Q1.3 (D), R74.2
DONE_1: U6.P$6 (DONE)
DTR: R12.2, U3.4 (DTR#), U4.4 (E2)
EC04_A: C64.2, R62.2, U9.26 (GPIO20), U55.A
EC04_B: C5.2, R6.2, U9.25 (GPIO19), U55.B
ESP32_EN: C17.2, R14.2, SW1.B, U4.6 (C1), U9.4 (CHIP_PU)
ESP_POWER_CTL: R27.2, U12.3 (P5.5/SS)
E_BUTTON: C66.2, R63.2, U9.24 (GPIO18), U55.D
GND: C1.1, C2.1, C3.2, C4.2, C5.1, C6.1, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.1, C14.1, C15.2, C16.1, C17.1, C18.1, C19.2, C20.1, C21.1, C22.1, C23.2, C24.2, C25.1, C26.1, C27.1, C28.2, C29.1, C30.2, C31.2, C32.2, C33.2, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C51.1, C52.2, C53.2, C64.1, C66.1, C67.2, C102.2, C103.2, C104.2, C105.1, C106.1, D1.1, D3.1, D4.1, FPC2.1, FPC2.15, FPC2.16, FPC2.17, FPC3.3, FPC3.4, FPC3.14, FPC3.16, FPC3.17, J2.1, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.P$1, J3.P$2, J3.P$3, J3.P$4, J4.1, J5.1, J6.1, J7.1, J7.3, J7.4, LED1.-, MIC3.4 (GND0), MIC3.6 (GND1), P5.P$1, P6.P$1, P8.1, P16.P$1, Q4.P$2, Q6.P$2, R3.1, R17.2, R19.1, R20.2, R28.2, R32.2, R33.1, R36.2, R38.1, R40.1, R75.1, R143.1, R171.2, SW1.1, SW1.2, SW1.3, SW1.4, SW1.A1, SW1.A2, SW2.1, SW2.2, SW2.3, SW2.4, SW2.A1, SW2.A2, SW3.1, SW3.2, SW3.3, SW3.4, SW3.A1, SW3.A2, U1.P$4 (VSS), U3.3 (GND), U3.EP, U5.P$2 (GND), U6.P$3 (GND), U6.P$9 (EP), U7.P$4 (NC1), U7.P$8 (GNDIO), U7.P$9 (GND), U8.4 (GND), U9.57 (EP), U10.21 (GND), U11.7 (GND), U11.9 (PE), U12.4 (GND), U12.P$9 (GND9), U13.2 (GND), U55.1, U55.2, U55.3, U55.COM, U55.E, X1.2 (G2), X1.4 (G1)
I2SOUT_LRCK: U9.52 (GPIO46), U11.2 (LRCLK)
I2SOUT_SCLK: U9.48 (MTMS), U11.3 (BCLK)
I2SOUT_SD: U9.47 (MTDI), U11.4 (SDATA)
IO0_BOOT: C21.2, R65.2, SW2.B, U4.3 (C2), U9.5 (GPIO0)
IO7_LCD_SCK: FPC3.10, U9.12 (GPIO7)
IO8_LCD_MOSI: FPC3.12, U9.13 (GPIO8)
IO9_LCD_CS: FPC3.9, U9.14 (GPIO9)
IO10_LCD_D/C: FPC3.11, U9.15 (GPIO10)
LCD_POWER_DET: R7.2, U9.19 (GPIO14)
LCD_RESET: FPC3.8, U9.11 (GPIO6)
LED: R42.2, U9.22 (XTAL_32K_N)
LEDA: FPC3.1, FPC3.2, R74.1
LEDK: FPC3.15, Q6.P$3
MIC_MCLK: R43.2, U9.17 (GPIO12)
MIC_SD2: R44.1, U9.16 (GPIO11)
MIC_VDD_3V3: C32.1, C33.1, FB1.2, MIC3.1 (VDD)
unnamed: ANT1.P$1, L2.2
unnamed: Q4.P$1, R2.2, R3.2
unnamed: C2.2, D007.C, J1.P$1, R1.2
unnamed: Q6.P$1, R75.2, R76.1
unnamed: C3.1, L1.1, U9.1 (LNA_IN)
unnamed: C4.1, L1.2, L2.1
unnamed: C8.1, U1.P$2 (OSCO), Y3.1
unnamed: C7.1, U1.P$1 (OSCI), Y3.2
unnamed: D007.A, J1.P$2, Q4.P$3
unnamed: R4.2, U13.1 (EN)
unnamed: L5.1, U13.3 (SW)
unnamed: R10.2, U3.9 (RXD)
unnamed: R11.2, U3.8 (TXD)
unnamed: R12.1, U4.2 (B1)
unnamed: C10.1, U3.10 (V3)
unnamed: R13.1, U4.5 (B2)
unnamed: MIC3.2 (CLK), R43.1
unnamed: L3.2, U9.54 (XTAL_P)
unnamed: Q1.1 (G), R56.1, R57.1
unnamed: J3.A5 (CC1), R20.1
unnamed: C12.2, U9.53 (XTAL_N), X1.3 (X2)
unnamed: C11.2, L3.1, X1.1 (X1)
unnamed: FPC3.13, R70.2
unnamed: C42.1, R15.2, R17.1, U13.5 (FB)
unnamed: MIC3.5 (L/R), R171.1
unnamed: C29.2, U10.1 (IOCAP)
unnamed: R7.1, U12.1 (P5.4/MOSI)
unnamed: C30.1, U10.15 (VCAP)
unnamed: R66.2, U10.20 (INT)
unnamed: R77.2, U10.19 (SDA)
unnamed: J3.B5 (CC2), R19.2
unnamed: LED1.+, R42.1
unnamed: R22.2, U7.P$10 (CS)
unnamed: R78.2, U10.18 (SCL)
unnamed: R16.2, U1.P$6 (SCL)
unnamed: R21.2, U1.P$5 (SDA)
unnamed: R24.2, U7.P$12 (SCX)
unnamed: R25.2, U7.P$2 (SDX)
unnamed: FB10.1, U11.8 (VOP)
unnamed: FB11.1, U11.5 (VON)
unnamed: MIC3.3 (DATA), R44.2
unnamed: R139.1, R143.2, U11.1 (CTRL)
unnamed: R31.1, R48.2, U6.P$1 (TEMP)
unnamed: P7.1, R31.2, R33.2
unnamed: R32.1, U6.P$2 (PROG)
unnamed: Q5.1 (G), R37.1, R38.2
unnamed: R79.2, U10.17 (RESX)
unnamed: Q7.1 (G), R9.2, R27.1
POWER_CTL: R4.1, U9.37 (SPICLK_P)
POWER_KEY: C36.2, R601.1, SW3.B, U12.8 (P3.3/MISO)
RTS: R13.2, U3.6 (RTS#), U4.1 (E1)
RX: P9.P$1, U9.44 (MTCK)
RXD0_H: R11.1, U9.50 (U0RXD)
RXD_STC: P2.P$1, U12.5 (P3.0/RXD)
S1: FPC2.2, U10.2 (S1)
S2: FPC2.3, U10.3 (S2)
S3: FPC2.4, U10.4 (S3)
S4: FPC2.5, U10.5 (S4)
S5: FPC2.6, U10.6 (S5)
S6: FPC2.7, U10.7 (S6)
S7: FPC2.9, U10.8 (S7)
S8: FPC2.10, U10.9 (S8)
S9: FPC2.11, U10.10 (S9)
S10: FPC2.12, U10.11 (S10)
S11: FPC2.13, U10.12 (S11)
S12: FPC2.14, U10.13 (S12)
SCL: P11.P$1, R16.1, R24.1, R29.2, R78.1, U9.8 (GPIO3)
SDA: P14.P$1, R21.1, R25.1, R26.2, R77.1, U9.9 (GPIO4)
SPICLK: U8.6 (CLK), U9.33 (SPICLK)
SPICS0: U8.1 (/CS), U9.32 (SPICS0)
SPID: U8.5 (DI_(IO0)), U9.35 (SPID)
SPIHD: U8.7 (/HOLD_OR_/RESET_(IO3)), U9.30 (SPIHD)
SPIQ: U8.2 (DO_(IO1)), U9.34 (SPIQ)
SPIWP: U8.3 (/WP_(IO2)), U9.31 (SPIWP)
TE: R70.1, U9.27 (GPIO21)
TOUCH_INT: R66.1, U9.7 (GPIO2)
TOUCH_RST: R79.1, U9.10 (GPIO5)
TX: P10.P$1, U9.43 (GPIO38)
TXD0_H: R10.1, U9.49 (U0TXD)
TXD_STC: P3.P$1, U12.6 (P3.1/TXD)
USB_D+: D1.2, R23.1, U3.1 (UD+)
USB_D-: D3.2, R18.1, U3.2 (UD-)
USB_POWER_DET: R39.2, R40.2, U9.23 (GPIO17), U12.7 (P3.2/SCLK)
VBUS: C9.1, C51.2, D4.2, D9.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R5.1, R37.2, R39.1, R48.1, U3.7 (VCC), U6.P$4 (VCC), U6.P$8 (CE)
VCC3V3: C18.2, C19.1, C23.1, C31.1, L4.2, P1.P$1, P15.P$1, Q7.3 (D), R6.1, R14.1, R26.1, R29.1, R62.1, R63.1, R65.1, U9.20 (VDD3P3_RTC), U9.46 (VDD3P3_CPU), U9.55 (VDDA_1), U9.56 (VDDA_2), U10.16 (VDDA)
VDD3P3: C15.1, C16.2, L4.1, U9.2 (VDD3P3_1), U9.3 (VDD3P3_2)
VDD3V3: C24.1, C28.1, C37.2, C38.2, C39.2, P4.P$1, Q7.2 (S), R9.1, R601.2, U1.P$8 (VDD), U5.P$5 (OUT), U12.2 (VCC)
VDD_SPI: C20.2, U8.8 (VCC), U9.29 (VDD_SPI)
VIB_EN: R2.1, U9.51 (GPIO45)
VIN: C6.2, C13.2, C34.2, C35.2, D9.2, Q5.2 (S), U5.P$1 (IN), U5.P$3 (EN), U13.4 (VIN)
VOLN: C106.2, FB11.2, P55.P$1
VOLP: C105.2, FB10.2, P54.P$1

Notes on the sheet:
RTC
POWER
350mA
Charging
ADC
MIC
GYRO
CS 1:SPI idle mode / I2C communication enabled
0: SPI communication mode / I2C disabled
FLASH
USB
ESP32 WATCH
Flat cable
RESET
ESP32-S3-R8
VIB
WIFI最大发射功率340mA
DISPLAY&TP
I=1000/R
BOOT
SPEAKER OUT
开机键 1、单击亮/灭屏 2、长按开/关机

Board: 4 copper layers, 32.4 x 39.8 mm, 178 parts (78 on the bottom side), 128 nets.

Notices in the files:
parts and their libraries:
SparkFun-Connectors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
